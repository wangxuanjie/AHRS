# Keil uVision project AHRS_F4.uvprojx, settings and files
target AHRS_F4 (6220000::V6.22::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: AHRS_F4 +hex (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx
  c misc: -Wno-unused-result -fno-finite-math-only
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Drivers\BSP;..\Modules\Eigen;..\Modules\Attitude;..\Modules\Calibrate;..\Modules\GCS;..\Modules\Math
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: retarget.c gpio.c dma.c i2c.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.cpp
  group Application/GCS
    ../Modules/GCS/: gcs.c gcs.h
  group Application/Calibration
    ../Modules/Calibrate/: Ellipsoid_fit.lib Ellipsoid_fit.h MagCalibration.cpp MagCalibration.h AccelCalibration.cpp AccelCalibration.h
  group Application/Attitude
    ../Modules/Attitude/: AttitudeEstimator.cpp AttitudeEstimator.h
  group Application/Math
    ../Modules/Math/: AHRS_Math.h AHRS_Math.cpp
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/BSP
    ../Drivers/BSP/: icm20602.c icm20602.h ist8310.c ist8310.h Params.c Params.h
software components: CMSIS:CORE 6.1.0, Compiler:I/O:STDOUT 1.2.0
